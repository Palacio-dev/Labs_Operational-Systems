## lab06/Kconfig
```kconfig
config ERROR_TRAN
    default m
    tristate "Zephyr error translation module"
    help
        placeholder
```
